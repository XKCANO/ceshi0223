# Keil uVision project KD001.uvprojx, settings and files
target KD001 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LF01X FMSH
  pack: FMSH.FM33LF0XX_DFP.2.0.1
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CO-0313-KD-001-A +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FM33LF0XX,USE_FULL_ASSERT
  c include: .\CMSIS\inc;.\Library\inc;.\User
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./CMSIS/src/: system_fm33lf0xx.c
    ./User/: startup_fm33lf0xx.s
  group User
    ./User/: main.c FM33LF0_System.c FM33LF0_Timer.c Keyboard_api.c Window_api.c Macro_definition.h Message_Process.c Adc_api.c Lcd_api.c FM33LF0_IIC.c Alarm_api.c Flash.c Ppm_Processing.c Calibrate_LED.c OPA_api.c OPA_api.h FM33LF0_UART.c FM33LF0_UART.h
  group Library
    ./Library/src/: fm33lf0xx_fl.c fm33lf0xx_fl_adc.c fm33lf0xx_fl_atim.c fm33lf0xx_fl_cmu.c fm33lf0xx_fl_gpio.c fm33lf0xx_fl_i2c_smbus.c fm33lf0xx_fl_iwdt.c fm33lf0xx_fl_lcd.c fm33lf0xx_fl_lptim16.c fm33lf0xx_fl_opa.c mf_config.c fm33lf0xx_fl_exti.c fm33lf0xx_fl_flash.c
